# Keil uVision project 2024.10.1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 2024.10.1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Objects\LCD1602.h
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h MatrixKey.h MatrixKey.c
